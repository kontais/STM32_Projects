# Keil uVision project STM32F103RB.uvprojx, settings and files
target STM32F103RB (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103RB +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\cmsis;.\cmsis_boot;.\STM32F10x_StdPeriph_Driver\inc;.\Drive\BLDC\inc;.\Drive\PID\inc;..\BLDC;.\Drive\KEY\inc;.\Drive\USART2\inc;.\Drive;.\Drive\delay;.\TFT_LCD;.\TFT_LCD\SPI;.\TFT_LCD\sys;.\TFT_LCD\LCD;.\Drive\RCC;.\Drive\Flash;..\STM32F103RBT6_BLDC控制PID;..\Bldc_Hall_STM32F103
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./: main.c stm32f10x_it.c
  group cmsis
    ./cmsis/: core_cm3.c
  group cmsis_boot
    ./cmsis_boot/: system_stm32f10x.c system_stm32f10x.h
  group startup
    ./cmsis_boot/startup/: startup_stm32f10x_md.s
  group PeriphLib
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BLDC
    ./Drive/BLDC/src/: BLDC.c
  group USER
    ./Drive/KEY/src/: KEY.c
    ./Drive/USART2/src/: USART2.c
    ./Drive/: PID.c ADC.c TIM.c EXTI.c
    ./Drive/delay/: delay.c
    ./Drive/RCC/: RCC.c
    ./Drive/Flash/: Flash.c
  group TFT_LCD
    ./TFT_LCD/LCD/: lcd.c
    ./TFT_LCD/SPI/: spi.c
    ./TFT_LCD/sys/: sys.c
